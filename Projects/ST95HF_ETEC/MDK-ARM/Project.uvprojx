# Keil uVision project Project.uvprojx, settings and files
target STM32F303xC (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F302VE STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.3.0
  cpu: IROM(0x08000000,0x00080000) IRAM(0x20000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F303xC
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F303xE,ST95HF
  c misc: --C99
  c include: ..\;..\..\..\Libraries\CMSIS\Include;..\..\..\Libraries\CMSIS\Device\ST\STM32F30x\Include;..\..\..\Libraries\STM32F30x_StdPeriph_Driver\inc;..\..\..\Libraries\STM32F30x_I2C_CPAL_Driver\inc;..\..\..\Libraries\95HF\inc;..\..\..\Libraries\NDEF\inc;..\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --diag_suppress=L6329
  group MDK-ARM
    ../../../Libraries/CMSIS/Device/ST/STM32F30x/Source/Templates/arm/: startup_stm32f30x.s startup_stm32f302x8.s startup_stm32f303xc.s startup_stm32f303xe.s startup_stm32f334x8.s
  group 95HF_Driver
    ../../../Libraries/95HF/src/: drv_95HF.c drv_interrupt.c drv_spi.c drv_uart.c
  group 95HF_PCD_Libraries
    ../../../Libraries/95HF/src/: lib_iso7816pcd.c lib_iso14443Apcd.c lib_iso14443Bpcd.c lib_iso15693pcd.c lib_iso18092pcd.c lib_nfctype1pcd.c lib_nfctype2pcd.c lib_nfctype3pcd.c lib_nfctype4pcd.c lib_nfctype5pcd.c lib_PCD.c
  group 95HF_PICC_Libraries
    ../../../Libraries/95HF/src/: lib_iso14443Apicc.c lib_PICC.c lib_PICCemulator.c lib_iso7816picc.c lib_nfctype2picc.c lib_nfctype4picc.c lib_cardemul.c
  group ST95HF_P2P_Libraries
    ../../../Libraries/95HF/lib/: DEMO_BOARD_ST95HF.lib
    ../../../Libraries/95HF/src/: lib_proprietaryP2P.c
  group STM32F30x_StdPeriph_Driver
    ../../../Libraries/STM32F30x_StdPeriph_Driver/src/: stm32f30x_adc.c stm32f30x_can.c stm32f30x_comp.c stm32f30x_crc.c stm32f30x_dac.c stm32f30x_dbgmcu.c stm32f30x_dma.c stm32f30x_exti.c stm32f30x_flash.c stm32f30x_fmc.c stm32f30x_gpio.c stm32f30x_hrtim.c stm32f30x_i2c.c stm32f30x_iwdg.c stm32f30x_misc.c stm32f30x_opamp.c stm32f30x_pwr.c stm32f30x_rcc.c stm32f30x_rtc.c stm32f30x_spi.c stm32f30x_syscfg.c stm32f30x_tim.c stm32f30x_usart.c stm32f30x_wwdg.c
  group 95HF_Manager_Libraries
    ../../../Libraries/95HF/src/: lib_ConfigManager.c
  group NDEF
    ../../../Libraries/NDEF/src/: lib_95HF_wrapper.c lib_flash_ndef.c lib_NDEF.c lib_NDEF_AAR.c lib_NDEF_Email.c lib_NDEF_Geo.c lib_NDEF_SMS.c lib_NDEF_Text.c lib_NDEF_URI.c lib_NDEF_Vcard.c
  group User
    ../src/: main.c stm32f30x_it.c system_stm32f30x.c common.c hw_config.c
software components: CMSIS:CORE 4.3.0
